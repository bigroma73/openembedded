require qt4-tools-sdk.inc

PR = "${INC_PR}.0"

DEFAULT_PREFERENCE = "-1"
