require avahi.inc

PR = "r2"

DEPENDS += "intltool-native"

PACKAGES =+ "libavahi-gobject"
